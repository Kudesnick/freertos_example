# Keil uVision project FreeRTOS_example.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./src/: main.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Message Buffer 10.0.1, RTOS:Stream Buffer 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
